FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://ls_color.cfg \
            file://devmem.cfg \
            "
